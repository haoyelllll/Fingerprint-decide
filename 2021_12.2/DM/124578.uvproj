# Keil uVision project 124578.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 124578 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\DM
  group Source Group 1
    ./: STARTUP.A51 stc89c52.h OLED_font.h delay.h delay.c buzz.h buzz.c led.h led.c Key.h Key.c OLED.h OLED.c AS608.h AS608.c main.c
